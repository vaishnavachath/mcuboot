## boot/zephyr/boards/beagleconnect_freedom.conf
```kconfig
CONFIG_I2C=n
CONFIG_I2C_TS5A2066=n
CONFIG_SENSOR=n
CONFIG_OPT3001=n
CONFIG_MCUBOOT_LOG_LEVEL_DBG=y
CONFIG_TI_HDC20XX=n
```
